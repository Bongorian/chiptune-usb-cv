#include "model.h"
#include "resources.h"
#include <math.h>
#include <stddef.h>
#include <string.h>
_Static_assert(sizeof(Patch) == 42 && sizeof(Track) == 70 && sizeof(Project) == 2116 &&
                   sizeof(Settings) == 10432,
               "v10 storage layout");
bool name_valid(const char name[9]) {
    if (name[8])
        return false;
    for (unsigned i = 0; i < 8; i++)
        if (name[i] < 32 || name[i] > 90)
            return false;
    return true;
}
void patch_default(Patch *p, unsigned chip) {
    memset(p, 0, sizeof(*p));
    p->chip = (uint8_t)chip;
    p->layers = 1;
    p->env_steps = 16;
    p->shape = 5;
    p->attack = 3;
    p->decay = 150;
    p->sustain = 100;
    p->release = 90;
    p->pitch_decay = 150;
    p->level = 65;
    p->retrigger = 1;
    p->noise_type = 1;
    p->noise_rate = 1;
    p->lfo_rate = 3;
    p->layer_level = 35;
    p->layer_decay = 80;
    p->stack_interval = 12;
    p->noise_mix = 50;
}
void patch_factory(unsigned index, Patch *p, char name[9]) {
    static const struct {
        char name[9];
        Patch patch;
    } factory[FACTORY_PATCHES] = {
#include "factory_data.inc"
    };
    index = index < FACTORY_PATCHES ? index : 20;
    *p = factory[index].patch;
    memcpy(name, factory[index].name, 9);
}
static bool between(int n, int lo, int hi) {
    return n >= lo && n <= hi;
}
bool patch_valid(const Patch *p) {
#define FIELD(n, t, lo, hi)                                                                        \
    if (!between(p->n, lo, hi))                                                                    \
        return false;
#include "sound_fields.inc"
#undef FIELD
    if (p->env_steps != 8 && p->env_steps != 16)
        return false;
    if (p->chip == CHIP_SAA) {
        if (p->env == ENV_OSC && p->source != SOURCE_TONE)
            return false;
        if (p->layers > 1 && (p->layers != 2 || p->env != ENV_OSC))
            return false;
    } else {
        if (p->env || (p->source != SOURCE_TONE && p->layers != 1))
            return false;
        if (p->source == SOURCE_MIX && p->noise_rate != 3)
            return false;
    }
    /* Swept noise is generated by the tracked clock; fixed rates have no continuous control. */
    if ((p->noise_pitch || p->noise_sweep) &&
        (p->noise_rate != 3 ||
         (p->source == SOURCE_TONE && !(p->chip == CHIP_SAA && p->layers > 1 && p->layer_source))))
        return false;
    return true;
}
PatchWave patch_wave(const Patch *p) {
    if (p->chip == CHIP_SAA && p->env)
        return p->env == ENV_OSC ? WAVE_ENV : WAVE_AM;
    if (p->source == SOURCE_MIX)
        return p->chip == CHIP_SAA ? WAVE_TONE_NOISE : WAVE_METAL;
    if (p->source == SOURCE_NOISE)
        return p->chip == CHIP_SN && p->noise_rate == 3 && !p->noise_type ? WAVE_PULSE : WAVE_NOISE;
    return WAVE_SQUARE;
}
bool patch_wave_available(unsigned chip, unsigned wave) {
    if (chip > CHIP_SN || wave >= WAVE_COUNT)
        return false;
    if (wave == WAVE_SQUARE || wave == WAVE_NOISE)
        return true;
    return chip == CHIP_SAA ? wave == WAVE_ENV || wave == WAVE_TONE_NOISE || wave == WAVE_AM
                            : wave == WAVE_PULSE || wave == WAVE_METAL;
}
bool patch_set_wave(Patch *p, unsigned wave) {
    if (!patch_wave_available(p->chip, wave) || !patch_valid(p))
        return false;
    if (patch_wave(p) == wave)
        return true;
    Patch q = *p;
    q.env = ENV_OFF;
    q.source = SOURCE_TONE;
    q.layers = 1;
    q.noise_pitch = q.noise_sweep = 0;
    if (wave == WAVE_PULSE || wave == WAVE_METAL) {
        q.source = wave == WAVE_PULSE ? SOURCE_NOISE : SOURCE_MIX;
        q.noise_rate = 3;
        q.noise_type = 0;
        q.noise_mix = 50;
    } else if (wave == WAVE_ENV || wave == WAVE_AM) {
        q.env = wave == WAVE_ENV ? ENV_OSC : ENV_AM;
        if (q.shape < 2)
            q.shape = 5;
    } else if (wave == WAVE_TONE_NOISE || wave == WAVE_NOISE) {
        q.source = wave == WAVE_TONE_NOISE ? SOURCE_MIX : SOURCE_NOISE;
        q.noise_rate = 1;
        q.noise_type = 1;
    }
    if (!patch_valid(&q))
        return false;
    *p = q;
    return true;
}
uint32_t patch_features(const Patch *p) {
    bool noise = p->source != SOURCE_TONE ||
                 (p->chip == CHIP_SAA && p->layers > 1 && p->layer_source != SOURCE_TONE);
    bool tracked = noise && p->noise_rate == 3;
    bool layer_pitch =
        p->layers > 1 && (p->chip == CHIP_SN || p->layer_source != SOURCE_NOISE || tracked);
    bool pitch = (p->source != SOURCE_NOISE && p->env != ENV_OSC) || (p->env && p->shape >= 2) ||
                 tracked || layer_pitch;
    uint32_t f = pitch ? PATCH_F_PITCH : 0;
    if (p->output == OUTPUT_STEREO)
        f |= PATCH_F_PAN;
    if (p->chip == CHIP_SAA && p->env)
        f |= PATCH_F_ENV;
    if (p->chip == CHIP_SAA && p->env == ENV_AM && p->shape >= 2)
        f |= PATCH_F_ENV_RATIO;
    if (noise)
        f |= PATCH_F_NOISE;
    if (noise && p->chip == CHIP_SN)
        f |= PATCH_F_NOISE_TYPE;
    if (tracked)
        f |= PATCH_F_NOISE_TRACK;
    if (p->chip == CHIP_SN && p->source == SOURCE_MIX)
        f |= PATCH_F_NOISE_MIX;
    if ((p->chip == CHIP_SN && p->source == SOURCE_TONE) ||
        (p->chip == CHIP_SAA && p->env == ENV_OSC))
        f |= PATCH_F_LAYERS;
    if (layer_pitch)
        f |= PATCH_F_LAYER_PITCH;
    if (p->chip == CHIP_SN && p->layers == 3)
        f |= PATCH_F_STACK;
    if (p->chip == CHIP_SAA && p->layers > 1)
        f |= PATCH_F_SAA_LAYER;
    if (p->chip == CHIP_SN && p->output == OUTPUT_STEREO && pitch)
        f |= PATCH_F_DETUNE;
    if (patch_wave(p) == WAVE_PULSE)
        f |= PATCH_F_PULSE;
    return f;
}
bool patch_same_structure(const Patch *a, const Patch *b) {
    if (a->chip != b->chip || a->source != b->source || a->env != b->env ||
        a->output != b->output || a->layers != b->layers)
        return false;
    if (a->chip == CHIP_SAA && a->layers > 1 && a->layer_source != b->layer_source)
        return false;
    if (a->env &&
        (a->shape != b->shape || a->env_steps != b->env_steps || a->env_invert != b->env_invert))
        return false;
    bool noise = a->source != SOURCE_TONE ||
                 (a->chip == CHIP_SAA && a->layers > 1 && a->layer_source != SOURCE_TONE);
    return !noise || (a->noise_rate == b->noise_rate &&
                      (a->chip == CHIP_SAA || a->noise_type == b->noise_type));
}
void patch_morph(Patch *out, const Patch *a, const Patch *b, unsigned amount) {
    *out = *a;
    if (!patch_same_structure(a, b))
        return;
    if (amount > 100)
        amount = 100;
#define BLEND(n)                                                                                   \
    out->n = (__typeof__(out->n))((int)a->n + ((int)b->n - (int)a->n) * (int)amount / 100)
    BLEND(attack);
    BLEND(decay);
    BLEND(release);
    BLEND(sustain);
    BLEND(level);
    BLEND(pitch_decay);
    BLEND(glide);
    BLEND(pitch_amount);
    BLEND(vibrato);
    BLEND(tremolo);
    BLEND(detune);
    BLEND(fine);
    BLEND(transpose);
    BLEND(layer_decay);
    BLEND(layer_level);
    BLEND(layer_interval);
    BLEND(stack_interval);
    BLEND(env_ratio);
    BLEND(noise_mix);
    BLEND(noise_pitch);
    BLEND(noise_sweep);
#undef BLEND
}
void project_default(Project *p) {
    memset(p, 0, sizeof(*p));
    memcpy(p->name, "MIDI 10 ", 9);
    p->mix[0] = 70;
    p->mix[1] = p->mix[2] = p->mix[3] = 100;
    p->sn_reference = 1;
    p->sn_trigger_source = 7;
    p->sn_clock = (SnClockConfig){SN_CLOCK_OFF, 0, 24, 4, 0, 1};
    p->tempo = 90;
    const uint8_t clocks[8] = {0, 50, 100, 25, 75, 100, 50, 0};
    memcpy(p->clock_sequence, clocks, 8);
    for (unsigned t = 0; t < TRACKS; t++) {
        Track *a = &p->track[t];
        a->enabled = t < 10;
        a->voices = 1;
        a->level = 100;
        a->pan = 50;
        a->high = 127;
        patch_factory(t < 6 ? 20 : t < 9 ? 21 : 22, &a->patch, a->name);
        const uint8_t dest[4] = {MOD_VIBRATO, MOD_TREMOLO, MOD_PAN, MOD_LEVEL};
        memcpy(a->macro_dest, dest, 4);
        Sequence *q = &p->sequence[t];
        q->length = 16;
        q->division = 6;
        q->arp_octaves = 1;
        for (unsigned i = 0; i < STEPS; i++) {
            q->note[i] = (uint8_t)(45 + (i % 4) * 3);
            q->gate[i] = 70;
            q->velocity[i] = 100;
        }
        if (t < 10)
            for (unsigned src = 0; src < SOURCES; src++)
                p->route[src][t] = (uint16_t)(1u << t);
    }
    for (unsigned i = 0; i < 2; i++)
        p->cv[i] = (CvRoute){.track = (uint8_t)i,
                             .gate_track = (uint8_t)i,
                             .base_note = 45,
                             .gate_note = 45,
                             .amount = 100};
}
void settings_default(Settings *s) {
    memset(s, 0, sizeof(*s));
    s->version = SETTINGS_VERSION;
    s->system.brightness = 70;
    s->system.cv_codes_per_volt[0] = s->system.cv_codes_per_volt[1] = 1.0f / .0006875f;
    for (unsigned i = 0; i < PROJECTS; i++)
        project_default(&s->project[i]);
    for (unsigned i = 0; i < USER_PATCHES; i++)
        patch_factory(i, &s->patches[i], s->patch_name[i]);
    s->patch_used = 0xffff;
    for (unsigned i = 0; i < USER_TRACKS; i++)
        s->tracks[i] = s->project[0].track[i % 10];
}
bool project_valid(const Project *p) {
    if (!name_valid(p->name) || p->sn_reference > 2 || p->sn_trigger_source > 7 ||
        p->clock_source >= SOURCES || p->clock_policy > 3 || p->gate_clock > 1 || p->tempo > 210 ||
        p->midi_thru > 1 || !sn_clock_valid(&p->sn_clock))
        return false;
    for (unsigned i = 0; i < 4; i++)
        if (p->mix[i] > 100)
            return false;
    for (unsigned i = 0; i < 8; i++)
        if (p->clock_sequence[i] > 100)
            return false;
    for (unsigned t = 0; t < TRACKS; t++) {
        const Track *a = &p->track[t];
        const Sequence *q = &p->sequence[t];
        if (!patch_valid(&a->patch) || !name_valid(a->name) || a->enabled > 1 ||
            a->mode > PLAY_LEGATO || !a->voices || a->voices > MAX_POLYPHONY || a->level > 100 ||
            a->pan > 100 || a->mute > 1 || a->low > a->high || a->high > 127 ||
            a->velocity_curve > 3 || a->morph_target > USER_PATCHES || a->morph > 100)
            return false;
        for (unsigned m = 0; m < 4; m++)
            if (a->macro_dest[m] >= MOD_PARAMS || a->macro[m] < -100 || a->macro[m] > 100)
                return false;
        if (q->enabled > 1 || !q->length || q->length > STEPS || !q->division || q->division > 24 ||
            q->direction > 2 || q->arp > 5 || !q->arp_octaves || q->arp_octaves > 4)
            return false;
        for (unsigned i = 0; i < STEPS; i++)
            if (q->note[i] > 127 || q->gate[i] > 100 || q->velocity[i] > 127 ||
                q->motion[i] < -100 || q->motion[i] > 100)
                return false;
    }
    for (unsigned s = 0; s < SOURCES; s++)
        for (unsigned c = 0; c < 16; c++)
            if (p->route[s][c] & 0xc000u)
                return false;
    for (unsigned i = 0; i < 2; i++) {
        const CvRoute *c = &p->cv[i];
        if (c->mode > 2 || c->track >= TRACKS || c->base_note > 127 || c->scale >= CV_SCALES ||
            c->root > 11 || c->glide > 7 || c->range > 1 || c->gate > 4 ||
            c->gate_track >= TRACKS || c->parameter >= MOD_PARAMS || c->gate_note > 127 ||
            c->amount < -100 || c->amount > 100)
            return false;
    }
    for (unsigned i = 0; i < MOD_SLOTS; i++)
        if (p->mod[i].source > 4 + TRACKS * 2 || p->mod[i].track >= TRACKS ||
            p->mod[i].parameter >= MOD_PARAMS || p->mod[i].amount < -100 || p->mod[i].amount > 100)
            return false;
    return !(p->cv[0].mode == 1 && p->cv[1].mode == 1 && p->cv[0].track == p->cv[1].track);
}
bool settings_valid(const Settings *s) {
    if (s->version != SETTINGS_VERSION || s->selected >= PROJECTS || s->system.brightness < 10 ||
        s->system.brightness > 100)
        return false;
    for (unsigned i = 0; i < 2; i++)
        if (!isfinite(s->system.cv_zero[i]) || fabsf(s->system.cv_zero[i]) > 16000 ||
            !isfinite(s->system.cv_codes_per_volt[i]) || s->system.cv_codes_per_volt[i] < 500 ||
            s->system.cv_codes_per_volt[i] > 3000)
            return false;
    for (unsigned i = 0; i < USER_PATCHES; i++)
        if ((s->patch_used & (1u << i)) &&
            (!patch_valid(&s->patches[i]) || !name_valid(s->patch_name[i])))
            return false;
    for (unsigned i = 0; i < USER_TRACKS; i++)
        if ((s->track_used & (1u << i)) &&
            (!patch_valid(&s->tracks[i].patch) || !name_valid(s->tracks[i].name)))
            return false;
    ResourcePlan plan;
    for (unsigned i = 0; i < PROJECTS; i++) {
        if (!project_valid(&s->project[i]) ||
            !resource_plan(&s->project[i], NULL, NULL, &plan, NULL))
            return false;
        for (unsigned t = 0; t < TRACKS; t++) {
            const Track *a = &s->project[i].track[t];
            if (a->morph_target &&
                (!(s->patch_used & (1u << (a->morph_target - 1))) ||
                 !patch_same_structure(&a->patch, &s->patches[a->morph_target - 1])))
                return false;
        }
    }
    return true;
}
